Commit message: added colored path in rrt

File: urdf/soln_arrow.urdf (robot description, URDF)
Before this commit: robot soln_arrow, 1 links, 0 joints
Links:
- link soln_arrow_link: geometry visual cylinder length=0.777 radius=0.011
